

SRC_URI="https://github.com/lkundrak/dev86/archive/v${PV}.zip"
 
SRC_URI[md5sum] = "799426b85f0f0cda58db2a6336cc26c5"
SRC_URI[sha256sum] = "37b44744e9de935bdd7d950d32fb9d84e53421c16e5425690a642ee39157f4e8"
 
